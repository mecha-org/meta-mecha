#RDEPENDS:${PN}:remove = " weston-init"
#RRECOMMENDS:${PN}:remove = " weston-init"